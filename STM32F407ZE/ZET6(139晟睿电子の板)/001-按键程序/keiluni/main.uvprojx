# Keil uVision project main.uvprojx, settings and files
target Target Main (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: STM32F407xx, _MCU_STM32F407ZE, USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\..\..\..\..\SVGN\unisym\inc\c;..\..\..\..\..\SVGN\unisym\inc\cpp;..\keiluni;..\stdlib\board\inc;..\..\..\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\LibSTM32CubeMX\CMSIS\Include;..\stdlib\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group
    ./: main.cpp
  group Library Unisym
    ../../../../../SVGN/unisym/lib/cpp/Device/: GPIO.cpp
  group Library Standard
    ../../../../LibSTM32CubeMX/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Depend Group
    ../../../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c
    ../../board/: system_stm32f4xx.c
    ../../board/src/: delay.c
