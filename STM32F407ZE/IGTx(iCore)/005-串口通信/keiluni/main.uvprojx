# Keil uVision project main.uvprojx, settings and files
target Target Main (6190000::V6.19::ARMCLANG)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: _MCU_STM32F407ZE, STM32F407xx, _MCU_STM32, _MCU_STM32F4x
  c include: ..\..\..\..\..\SVGN\unisym\inc\c;..\..\..\..\..\SVGN\unisym\inc\cpp;..\..\..\..\LibSTM32CubeMX\CMSIS\Include;..\..\..\..\LibSTM32CubeMX\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\LibSTM32CubeMX\STM32F4xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group
    ./: main.cpp
  group Library Unisym
    ../../../../../SVGN/unisym/lib/cpp/Device/: GPIO.cpp RCC.cpp SysTick.cpp NVIC.cpp UART.cpp
    ../../../../../SVGN/unisym/lib/cpp/MCU/: STM32F4.cpp
    ../../../../../SVGN/unisym/lib/cpp/: interrupt.cpp
    ../../../../../SVGN/unisym/lib/cpp/Device/Interrupt/: interrupt_tab.cpp
  group Library Standard
    ../../../../LibSTM32CubeMX/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../../../LibSTM32CubeMX/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
