# Keil uVision project main.uvprojx, settings and files
target main (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX, STM32F407xx, _MCU_STM32F407ZE
  c include: ..\inc;..\..\..\board\inc;..\..\..\..\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\..\SVGN\unisym\inc\c;..\..\..\..\..\..\SVGN\unisym\inc\cpp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../src/: system_stm32f4xx.c
    ../../../../../LibSTM32CubeMX/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../../../../LibSTM32CubeMX/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group user
    ../src/: stm32f4xx_it.c main.cpp
  group board
    ../../../board/src/: delay.c key.c lcd.c led.c rtc.c timer.c usart.c touch.c spi.c
  group periph
    ../../../../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_usart.c stm32f4xx_pwr.c stm32f4xx_fsmc.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_spi.c
  group unisym
    ../../../../../../SVGN/unisym/lib/cpp/Device/: GPIO.cpp
software components: CMSIS:CORE 5.6.0
