# Keil uVision project main.uvprojx, settings and files
target Target Main (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: STM32F103xE, _MCU_STM32F103VE,  USE_HAL_DRIVER
  c include: ..\..\..\..\SVGN\unisym\inc\c;..\..\..\..\SVGN\unisym\inc\cpp;..\..\cominc;..\..\..\LibSTM32CubeMX\STM32F1xx_HAL_Driver\Inc;..\..\..\LibSTM32CubeMX\CMSIS\Include;..\..\..\LibSTM32CubeMX\CMSIS\Device\ST\STM32F1xx\Include;..\keilult
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group
    ./: main.cpp main.h
  group Library Unisym
    ../../../../SVGN/unisym/lib/cpp/Device/: GPIO.cpp RCC.cpp SysTick.cpp AFIO.cpp NVIC.cpp TIM.cpp IIC.cpp ADC.cpp
    ../../../../SVGN/unisym/lib/cpp/Device/Interrupt/: interrupt_tab.cpp
    ../../../../SVGN/unisym/lib/cpp/: interrupt.cpp
  group Library Standard
    ../../comlib/: led.cpp key.cpp system.cpp bsp_spi_flash.c bsp_sdram.c bsp_ili9341_lcd.c bsp_debug_usart.c fonts.cpp bsp_xpt2046_lcd.cpp lcd.cpp
    ../../0n-LCD-ST7789V-XPT2046-3.2inch/keilult/: palette.cpp
  group Library Dependent
    ../../../LibSTM32CubeMX/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../../LibSTM32CubeMX/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_gpio.c stm32f1xx_ll_usart.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c stm32f1xx_hal_sram.c stm32f1xx_hal_dma.c stm32f1xx_ll_fsmc.c
    ../../../LibStarter/: startup_stm32f103xe.s
