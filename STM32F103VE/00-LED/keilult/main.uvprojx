# Keil uVision project main.uvprojx, settings and files
target Target Main (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: STM32F103xE, _MCU_STM32F103VE
  c include: E:\tmp\STM32Cube_FW_F1_V1.6.0\Drivers\CMSIS\Device\ST\STM32F1xx\Include;E:\tmp\STM32Cube_FW_F1_V1.6.0\Drivers\CMSIS\Include;..\..\..\..\SVGN\unisym\inc\c;..\..\..\..\SVGN\unisym\inc\cpp
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group
    ./: main.cpp
  group Library Unisym
    ../../../../SVGN/unisym/lib/cpp/Device/: GPIO.cpp
  group Library Standard
    ./ST/: system_stm32f1xx.c
    ./ST/arm/: startup_stm32f103xe.s
    ./Embedfire/: led.cpp
