# Keil uVision project main.uvprojx, settings and files
target Target Main (6190000::V6.19::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _MCU_CW32F030
  c include: ..\..\..\SVGN\unisym\inc\c;..\..\..\SVGN\unisym\inc\cpp;..\..\LibCWOfficial\CW32F030\inc;.\
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Group Source
    ./: main.cpp system_cw32f030.c
  group Group Unisym
    ../../../SVGN/unisym/lib/cpp/Device/: GPIO.cpp
    ../../LibStarter/: startup_cw32f030.s
software components: CMSIS:CORE 5.6.0
