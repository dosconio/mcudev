# Keil uVision project main.uvproj, settings and files
target main (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: keilout +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: _MCU_Intel8051, _IMPLEMENT_KEIL8051
  c include: ..\..\..\..\SVGN\unisym\inc\c;..\..\cominc
  group Source Group
    ./: STARTUP.A51 main.c
  group Unisym Group
    ../../../../SVGN/unisym/lib/c/processor/8051/: delay11M.c
    ../../../../SVGN/unisym/lib/c/driver/: IIC.c OneWire.c
    ../../../../SVGN/unisym/lib/c/driver/device/: AT24C02.c DS18B20.c
    ../../../../SVGN/unisym/lib/c/driver/device/nixietube/: nixietube.c
  group Comlib Group
    ../../comlib/: timer51.c btnkey.c
