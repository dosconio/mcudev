# Keil uVision project lcd1602keil.uvproj, settings and files
target LCD1602Keil (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: lcd1602keil +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\SVGN\unisym\inc\c
  group Source Group
    ./: STARTUP.A51 main.c
  group Unisym Group
    ../../../../SVGN/unisym/lib/c/driver/: HD44780.c
    ../../../../SVGN/unisym/lib/c/driver/device/: LCD1602.c
    ../../../../SVGN/unisym/lib/c/processor/8051/: delay11M.c
